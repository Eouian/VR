# Keil uVision project F1C100S.uvproj, settings and files
target F1C100S (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: F1C100S
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: ..\Project\EXEC ..\Project\obj\F1C100S.bin ..\Project\f1c100s.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c misc: --diag_suppress=1081
  c include: ..\Driver\Include;..\Project;..\USR\bmp
  memory RVCT1: ROM 0x0 size 0x4000
  memory RVCT4: ROM 0x80000000 size 0x10000
  memory RVCT6: RAM 0x4000 size 0x4000
  memory RVCT9: RAM 0x80010000 size 0xffffffff
  scatter file: ..\Script\F1C100S.sct
  link misc: --entry 0x80000000
  group src
    ./: main.c mconf.h
    ../Driver/Source/: standalone.c sys_start.s vectors.s
  group Libraries
    ../Driver/Source/: sys_clock.c sys_uart.c sys_delay.c sys_ctl.s sys_interrupt.c sys_timer.c sys_mmu.c arm32.c sys_cache.c sys_lcd.c sys_defe.c sys_tve.c sys_tvd.c sys_lcd_gui_argb32.c sys_gpio.c
  group bmp
    ../USR/bmp/: sys_bmp.c
